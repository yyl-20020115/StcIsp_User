# Keil uVision project stc_uart_user_isp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc_uart_user_isp +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./src/: isr.asm main.c iap.c dfu.c uart.c
